## config/Kconfig
```kconfig
config DEBUG
	bool "Enable DEBUG"
	default n
	help
		This option enables the 'DEBUG' functionality.
```
